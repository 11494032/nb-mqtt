# Keil uVision project app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA,USE_NB
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Src;../Ali;../Common;../DriversInterface/nb;../Third_Party/mbedtls-2.16.0/library;../Third_Party/mbedtls-2.16.0/include/;../Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTClient-C/src;../Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTPacket/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group AliIoT
    ../Ali/: Ali_iot_network_wrapper.c Ali_iot_network_wrapper.h Ali_iotclient.c Ali_iotclient.h mqtt_msg_handler.c
  group Common
    ../Common/: msg.h nb_net.c net.c net.h net_internal.h net_tcp_nb.c paho_mqtt_platform.h paho_timer.c paho_timer.h version.h
  group NB
    ../DriversInterface/nb/: nb.c nb_io.c kfifo.c kfifo.h nb_io.h
  group User
    ../Src/: app.c config_hmacsha1.h custom_errno.h app.h
  group mbedtls
    ../Third_Party/mbedtls-2.16.0/library/: md.c md_wrap.c platform_util.c sha1.c
    ../Third_Party/mbedtls-2.16.0/include/mbedtls/: md.h platform_util.h
  group mqttClient
    ../Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTClient-C/src/: MQTTClient.c MQTTClient.h
  group mqttPacket
    ../Third_Party/paho.mqtt.embedded-c-1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 4.3.0
